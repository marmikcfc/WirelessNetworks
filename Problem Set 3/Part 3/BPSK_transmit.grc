<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>my_constellation</value></param>
<param><key>const_points</key><value>[-1, 1]</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>30</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>100000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ubuntu/trx_1.bin</value></param>
<param><key>type</key><value>int</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ubuntu/rx_1.bin</value></param>
<param><key>type</key><value>int</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>/home/ubuntu/rx_30.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1</value></param>
<param><key>file</key><value>/home/ubuntu/trx_30.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>100000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>100000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0_0</value></param>
<param><key>num_items</key><value>100000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_1</value></param>
<param><key>num_items</key><value>100000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>-1, 1</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>-1, 1</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>my_constellation</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_head_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_1</source_block_id><sink_block_id>blocks_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_head_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
